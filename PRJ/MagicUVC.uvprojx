# Keil uVision project MagicUVC.uvprojx, settings and files
target MagicUVC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MagicUVC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\INC;..\CMSIS;..\uCOS\uC-CPU;..\uCOS\uC-CPU\ARM-Cortex-M4\RealView;..\uCOS\uC-LIB;..\uCOS\uCOS-III\Source;..\uCOS\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\USER;..\INC\applications;..\INC\drivers;..\LIB\USBStack\INC;..\LIB\FatFS\src;..\LIB\USBStack\INC;..\SRC\applications;..\LIB\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../SRC/: main.c
    ./: startup_stm32f40_41xxx.s
    ../SRC/applications/: stm32f4xx_it.c
  group APP
    ../SRC/applications/: Ano_OF.c anotc_baro_ctrl.c ctrl.c data_transfer.c filter.c fly_mode.c height_ctrl.c imu.c init.c mymath.c parameter.c PID.c rc.c usb_config.c usbd_user_hid.c version.c task.c
    ../LIB/FatFS/src/: ff.c diskio.c
    ../LIB/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group BSP
    ../SRC/: sys.c bsp.c
    ../SRC/drivers/: ak8975.c drv_w25qxx.c i2c_soft.c led.c mpu6050.c ms5611.c pwm_in.c pwm_out.c time.c ultrasonic.c usart.c usbd_STM32F4xx_FS.c
  group StdLIB
    ../LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
    ../USER/: system_stm32f4xx.c
  group uC/CPU
    ../uCOS/uC-CPU/: cpu_core.c
    ../uCOS/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../uCOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOS/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III SRC
    ../uCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III PORT
    ../uCOS/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
